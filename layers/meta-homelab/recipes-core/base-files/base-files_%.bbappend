FILESEXTRAPATHS:prepend:homelab := "${THISDIR}/files:"
